<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\MO工程建立.ewp</path>
  </project>
  <batchBuild />
</workspace>
